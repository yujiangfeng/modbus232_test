# Keil uVision project 232.uvprojx, settings and files
target modbus232 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: 232
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ..\User\inc;..\Modbus\include;..\Std_Driver\inc;..\CMSIS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../CMSIS/: startup_stm32f10x_hd.s
  group SMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c stm32f10x.h stm32f10x_conf.h
  group Std_Driver
    ../Std_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rcc.c stm32f10x_gpio.c
  group User
    ../User/src/: main.c stm32f10x_it.c
  group Modbus
    ../Modbus/ascii/: mbascii.c
    ../Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Modbus/port/: port.c portevent.c portserial.c porttimer.c
    ../Modbus/rtu/: mbcrc.c mbrtu.c
    ../Modbus/: mb.c
software components: CMSIS:CORE 4.3.0
